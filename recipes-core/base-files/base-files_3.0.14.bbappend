FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}/share:"
