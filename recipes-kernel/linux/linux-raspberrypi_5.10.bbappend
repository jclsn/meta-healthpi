LINUX_VERSION ?= "5.10.95"

SRCREV_machine = "${AUTOREV}"
SRCREV_meta = "${AUTOREV}"
